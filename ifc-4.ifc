Properties of the parts of a building model (IFC4)

# File
Description: Raumtemperaturregler, Aufputz, 5…30 °C, 230 VAC, Wechsler, Schalter EIN/AUS, Ausgang Ventilator, ViewDefinition[CoordinationView]
File name: ifc-4.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: MA010900, Raumtemperaturregler, Aufputz, 5…30 °C, 230 VAC, Wechsler, Schalter EIN/AUS, Ausgang Ventilator
In: Raum
Description: Elektromechanischer Raumtemperaturregler im Aufputzgehäuse zur Regelung oder Überwachung von Temperaturen in Büros, Wohnräumen und Hotels. Geeignet für alle Heizungsarten. Durch die thermische Rückführung wird eine sehr genaue Schaltdifferenz erreicht. Mit der unter dem Einstellknopf befindlichen Bereichseinengung kann der Einstellbereich verändert werden. Das Gerät verfügt über einen Schalter EIN/AUS. Der Ventilatorausgang ist dauerhaft mit 230 VAC geschaltet, wenn das Gerät eingeschaltet ist.; Classification: EC010927 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: MA010900; ModelLabel: RTBSB-001.026; GlobalTradeItemNumber: 4050528049728; ProductURL: https://alre.de/produkt_MA010900
Pset_Specification - NominalLength: 0.0834 m; NominalWidth: 0.0783 m; NominalDepth: 0.0255 m; NetWeight: 0.079
Pset_ALRE_ETIM_Properties - Montageart: Aufputz; Farbe: weiß; Breite: 78.3; Höhe: 83.4; Tiefe: 25.5; RAL-Nummer: 9010; Anschluss: sonstige; Art der Spannungsversorgung: 230 V AC; Kontaktausführung: Wechsler (NO/NC); Messbereich: 5; Bedienung: Dreh; Explosionsgeschützt: no; Schutzart (IP): IP30; Ausführung Aufnehmer/Fühler: Bimetall; Klasse des Temperaturreglers: I; Schutzart (NEMA): sonstige; Verdeckte Bedienung: no; Max. Spannung der Kontakte: 230; Mit Empfänger: no; Regelcharakteristik: P; Anzahl der Ausgänge Heizung: 1; Anzahl der Ausgänge Kühlung: 1; Temperatur ablesbar: no; Max. Kontaktbelastung: 10; Differenzwert: 0.5; Sensor extern: no; Thermische Rückkopplung: parallel; Differenz verstellbar: no; Geeignet für Heizung: yes; Geeignet für Kühlen: yes; ETIM-Klasse: EC010927; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-MA010900.pdf
